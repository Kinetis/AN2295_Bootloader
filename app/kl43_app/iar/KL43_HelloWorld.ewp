# IAR project KL43_HelloWorld.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL43Z256xxx4 Freescale MKL43Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; NDEBUG; CPU_MKL43Z256VMP4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../devices/MKL43Z4/utilities; ../devices/MKL43Z4; ../devices/MKL43Z4/iar; ../devices/MKL43Z4/drivers; ../CMSIS/Include; ../../..; ../
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: KL43_HelloWorld.srec
  ILINK.IlinkOutputFile: KL43_HelloWorld.out
  ILINK.IlinkIcfFile: MKL43Z256xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 5
  ICCARM.CCDefines: NDEBUG; CPU_MKL43Z256VMP4
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MKL43Z256xxx4_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0plus.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../devices/MKL43Z4/: fsl_device_registers.h MKL43Z4.h MKL43Z4_features.h
  group drivers
    ../devices/MKL43Z4/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_cop.c fsl_cop.h fsl_dac.c fsl_dac.h fsl_dma.c fsl_dma.h fsl_dmamux.c fsl_dmamux.h fsl_flash.c fsl_flash.h fsl_flexio.c fsl_flexio.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_dma.c fsl_flexio_i2s_dma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_dma.c fsl_flexio_uart_dma.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_dma.c fsl_i2c_dma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_dma.c fsl_lpuart_dma.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai.h fsl_sai_dma.c fsl_sai_dma.h fsl_sim.c fsl_sim.h fsl_slcd.c fsl_slcd.h fsl_smc.c fsl_smc.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_tpm.c fsl_tpm.h fsl_uart.c fsl_uart.h fsl_uart_dma.c fsl_uart_dma.h fsl_vref.c fsl_vref.h
  group sources
    ../: main.c
  group startup
    ../devices/MKL43Z4/iar/: startup_MKL43Z4.s
    ../devices/MKL43Z4/: system_MKL43Z4.c system_MKL43Z4.h
  group utilities
    ../devices/MKL43Z4/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_notifier.c fsl_notifier.h fsl_sbrk.c
