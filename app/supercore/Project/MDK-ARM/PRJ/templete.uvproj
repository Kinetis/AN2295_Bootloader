# Keil uVision project templete.uvproj, settings and files
target Template (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: templete
  c flags: Optim=1
  c include: ..\..\..\Libraries\Startup\MDK;..\..\..\Libraries\Drivers\inc;..\..\..\Libraries\Devices\LED;..\..\..\Libraries\Devices\MMA845x
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Startup
    ../../../Libraries/Startup/MDK/: startup_MKL25Z4.s system_MKL25Z4.c
  group User
    ../../src/: main.c isr.c test.c
  group Drivers
    ../../../Libraries/Drivers/src/: adc.c delay.c dma.c gpio.c i2c.c pit.c spi.c sys.c uart.c wdog.c
  group Devices
    ../../../Libraries/Devices/LED/: led.c
    ../../../Libraries/Devices/MMA845x/: mma845x.c
