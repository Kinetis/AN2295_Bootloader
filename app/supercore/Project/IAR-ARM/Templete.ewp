# IAR project Templete.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\Libraries\Drivers\inc; ..\..\Libraries\Startup\IAR; ..\..\Libraries\User; ..\..\Libraries\Devices\MAG3110; ..\..\Libraries\Devices\LED; ..\..\Libraries\Devices\SPIFLASH; ..\..\Libraries\Devices\24LC512; ..\..\Libraries\Devices\MMA845x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Templete.srec
  ILINK.IlinkOutputFile: Templete.out
  ILINK.IlinkIcfFile: config\128KB_Pflash_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Devices/24LC512
    ../../Libraries/Devices/24LC512/: at24cxx.c
  group Devices/LED
    ../../Libraries/Devices/LED/: led.c
  group Devices/MAG3110
    ../../Libraries/Devices/MAG3110/: mag3110.c
  group Devices/MMA845x
    ../../Libraries/Devices/MMA845x/: mma845x.c mma845x.h
  group Devices/SPIFLASH
    ../../Libraries/Devices/SPIFLASH/: spiflash.c
  group Drivers
    ../../Libraries/Drivers/src/: adc.c delay.c dma.c flash.c gpio.c i2c.c pit.c pmc.c rcm.c spi.c sys.c uart.c wdog.c
  group Startup
    ../../Libraries/Startup/IAR/: crt0.s startup.c startup_MKL25Z4.s system_MKL25Z4.c
  group User
    ../src/: isr.c isr.h main.c test.c
