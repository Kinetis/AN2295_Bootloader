# IAR project Uart_demo_frdm.ewp, settings and files
configuration FLASH_32KB_PFLASH (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; FRDM_MA64
  ICCARM.CCIncludePath2: ..\..\..\src\projects\Uart_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\ftm; ..\..\..\src\drivers\ics; ..\..\..\src\drivers\mtim; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\nvm; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FRDM_KE02_Uart_demo_frdm.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\MA64_Flash_32K_Bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_4KB (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: Uart_demo_frdm.srec
  ILINK.IlinkIcfFile: ..\config files\MA64_RAM_4KB.icf
configuration FLASH_64KB_PFLASH (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: Uart_demo_frdm.srec
  ILINK.IlinkIcfFile: ..\config files\MA64_Flash_64K.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s dma_channels.h start.c start.h sysinit.c sysinit.h systick.c systick.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MKE02Z2.h
  group drivers/ICS
    ../../../src/drivers/ics/: ics.c ics.h
  group drivers/RTC
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/UART
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/WDOG
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 128KB_Pflash.icf 16KB_RAM.icf 32KB_Pflash.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: MA64_freedom.c MA64_freedom.h
  group project
    ../../../src/projects/Uart_demo/: isr.h Uart_demo.c
