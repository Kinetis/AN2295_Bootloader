# IAR project KV31_app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV31F512xxx12 Freescale MKV31F512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MKV31F512VLL12; FSL_RTOS_BM; NDEBUG
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../devices/MKV31F51212; ../devices/MKV31F51212/utilities; ../devices/MKV31F51212/iar; ../devices/MKV31F51212/drivers; ../CMSIS/Include; ../../..; ../
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: KV31_app.srec
  ILINK.IlinkOutputFile: KV31_app.out
  ILINK.IlinkIcfFile: MKV31F512xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 41
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MKV31F512xxx12_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../devices/MKV31F51212/: fsl_device_registers.h MKV31F51212.h MKV31F51212_features.h
  group drivers
    ../devices/MKV31F51212/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group sources
    ../: main.c
  group startup
    ../devices/MKV31F51212/iar/: startup_MKV31F51212.s
    ../devices/MKV31F51212/: system_MKV31F51212.c system_MKV31F51212.h
  group utilities
    ../devices/MKV31F51212/utilities/: fsl_debug_console.c fsl_debug_console.h
