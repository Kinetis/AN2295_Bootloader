<?xml version='1.0' encoding='iso-8859-1'?>
<workspace>
	<batchBuild>
		<batchDefinition>
			<name>all</name>
			<member>
				<project>HelloWorld</project>
				<configuration>Release</configuration>
			</member>
			<member>
				<project>HelloWorld</project>
				<configuration>Debug</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>Release</name>
			<member>
				<project>HelloWorld</project>
				<configuration>Release</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>Debug</name>
			<member>
				<project>HelloWorld</project>
				<configuration>Debug</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
	<project>
		<path>$WS_DIR$/HelloWorld.ewp</path>
	</project>
</workspace>