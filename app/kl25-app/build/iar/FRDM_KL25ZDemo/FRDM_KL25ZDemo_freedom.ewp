# IAR project FRDM_KL25ZDemo_freedom.ewp, settings and files
configuration FLASH_128KB (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; FREEDOM
  ICCARM.CCIncludePath2: ..\..\..\src\projects\FRDM_KL25ZDemo; ..\..\..\src\projects\FRDM_KL25ZDemo\usb; ..\..\..\src\projects\FRDM_KL25ZDemo\bsp; ..\..\..\src\projects\FRDM_KL25ZDemo\freedom_gpio; ..\..\..\src\projects\FRDM_KL25ZDemo\pit; ..\..\..\src\projects\FRDM_KL25ZDemo\tsi; ..\..\..\src\projects\FRDM_KL25ZDemo\task_mgr; ..\..\..\src\projects\FRDM_KL25ZDemo\angle_calculation; ..\..\..\src\projects\FRDM_KL25ZDemo\i2c; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\lpsci; ..\..\..\src\drivers\sci; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FRDM_KL25ZDemo_freedom.srec
  ILINK.IlinkOutputFile: platinum_freedom.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_64KB (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash.icf
configuration FLASH_32KB (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\config files\32KB_Pflash.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MKL25Z4.h
  group drivers/cmp
    ../../../src/drivers/cmp/: cmp.c cmp.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group IAR
    ../config files/: 128KB_Pflash.icf 16KB_RAM.icf 32KB_Pflash.icf 4KB_RAM.icf 64KB_Pflash.icf 8KB_RAM.icf
    ../: iar.h
  group project
    ../../../src/projects/FRDM_KL25ZDemo/: FRDM_KL25ZDemo.c freedom.h FslTypes.h global.c global.h isr.h sysinit.c
  group project/anlge_calculation
    ../../../src/projects/FRDM_KL25ZDemo/angle_calculation/: angle_cal.c angle_cal.h asin.c asin.h median.c median.h sqrt16.c sqrt16.h
  group project/bsp
    ../../../src/projects/FRDM_KL25ZDemo/bsp/: bsp_KL25.c bsp_KL25.h
  group project/freedom_gpio
    ../../../src/projects/FRDM_KL25ZDemo/freedom_gpio/: freedom_gpio.c freedom_gpio.h
  group project/I2C
    ../../../src/projects/FRDM_KL25ZDemo/I2C/: hal_dev_mma8451.c hal_dev_mma8451.h hal_i2c.c hal_i2c.h
  group project/pit
    ../../../src/projects/FRDM_KL25ZDemo/pit/: pit.c pit.h
  group project/task_mgr.c
    ../../../src/projects/FRDM_KL25ZDemo/task_mgr/: task_mgr.c task_mgr.h
  group project/tsi
    ../../../src/projects/FRDM_KL25ZDemo/tsi/: TSIDrv.c TSIDrv.h
  group project/usb
    ../../../src/projects/FRDM_KL25ZDemo/usb/: ring_buffer.c ring_buffer.h usb.c usb.h usb_cdc.c usb_cdc.h usb_descriptor.h usb_reg.c usb_reg.h
