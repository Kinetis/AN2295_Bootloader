# IAR project UART_Init.ewp, settings and files
configuration FLASH_256 (ARM, debug)
  General.OGChipSelectEditMenu: MKV46F256xxx15 Freescale MKV46F256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_KV40F256; DEBUG_MODE; TOWER
  ICCARM.CCIncludePath2: ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\drivers\adc; ..\..\..\src\drivers\dsp; ..\..\..\src\drivers\enet; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\..\..\src\projects\$PROJ_FNAME$; ..\..\..\src\projects\$PROJ_FNAME$\peripherals; ..\..\..\src\FreeMASTER
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UART_Init.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\Example_Official\KV4x-TWR example codes\build\iar\KV4x\config_files\256KB_Pflash_Bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group config
    ../KV4x/config_files/: 256KB_Pflash.icf
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s dma_channels.h start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group drivers/ADC
    ../../../src/drivers/ADC/: adc.c adc.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group Peripherals
    ../../../src/projects/UART_Init/: app_init.c app_init.h peripherals_init.c peripherals_init.h
  group platforms
    ../../../src/platforms/: iar.h MKV46F15.h TWR-KV46F256.h
  group Sources
    ../../../src/projects/UART_Init/: isr.h main.c
